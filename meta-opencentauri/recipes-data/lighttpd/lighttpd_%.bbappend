RDEPENDS:${PN}:append = " lighttpd-module-proxy"